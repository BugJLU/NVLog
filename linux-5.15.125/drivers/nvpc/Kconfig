## linux-5.15.125/drivers/nvpc/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-only
config LIBNVPC
    tristate "Library to control NVPC"
    default y
    select NVPC
```
